# IAR project CC2530.ewp, settings and files
configuration srf05_cc2530 (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../source/Components/utils; ../source/Components/common; ../source/Components/basicrf; ../source/Components/flash; ../source/Components/targets/interface; ../source/Components/assembly; ../source/Components/common/cc8051; ../source/Components/targets/srf05_soc; ../source/Components/radios/cc2530
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  postbuild: hex2bin.exe -s 0 "CC2530_SENSOR_bl.hex"
  XLINK.XclFile: ..\f8w2530.xcl
  group application
    ../source/apps/: CC2530.c
  group basic rf
    ../source/components/basicrf/: basic_rf.c basic_rf.h
  group flash
    ../source/components/flash/: flash.c flash.h
  group hal/common
    ../source/components/common/cc8051/: hal_cc8051.h
    ../source/components/common/: hal_defs.h hal_int.c hal_types.h
  group hal/interface
    ../source/components/targets/interface/: hal_assert.h hal_button.h hal_digio.h hal_int.h hal_led.h hal_mcu.h
  group hal/rf
    ../source/components/targets/interface/: hal_rf.h
  group hal/rf/cc2530
    ../source/components/radios/cc2530/: clock.c clock.h hal_mcu.c hal_rf.c hal_rf_security.c
  group hal/srf05_soc
    ../source/components/targets/srf05_soc/: C51_Gpio.c C51_Rtc.c hal_assert.c hal_board.c hal_board.h hal_button.c hal_digio.c hal_led.c
  group utilities
    ../source/components/utils/: hal_i2c.c hal_i2c.h util.c util.h util_buffer.c util_buffer.h
